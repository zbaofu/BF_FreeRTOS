# Keil uVision project MyRTOS_1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: MyRTOS_1
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\User;..\freertos\include;..\freertos\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c
  group FreeRTOS/Source
    ../freertos/include/: list.h portmacro.h FreeRTOSConfig.h FreeRTOS.h task.h projdefs.h portable.h
    ../freertos/Source/: list.c task.c
    ../freertos/portable/RVDS/ARM_CM3/: port.c
  group doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
